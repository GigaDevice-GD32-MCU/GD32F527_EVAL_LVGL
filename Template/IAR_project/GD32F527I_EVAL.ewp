# IAR project GD32F527I_EVAL.ewp, settings and files
configuration GD32F527 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32F527; LV_CONF_INCLUDE_SIMPLE; GD32F527_EVAL; RESISTIVE_TOUCH_SCREEN
  ICCARM.CCDiagSuppress: Pa167,Pe170,Pe236,Pa084,Pe550,Pa118,Pe111,Pe549,Pa089,Pe174,Pe188,Pe546,Pe186,Pe177
  ICCARM.CCIncludePath2: ..; ..\..\Utilities\lvgl\lvgl; ..\GUI_APP\ui_lvgl\demos; ..\..\Utilities\lvgl\lvgl_port; ..\..\Utilities\fatfs\fatfs; ..\..\Utilities\fatfs\fatfs_port; ..\..\Utilities\bsp_drive; ..\..\Firmware\GD32F527_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32F527\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F527I_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: GD32F527xS_custom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f527_it.c main.c systick.c taskmain.c
  group bsp_drive
    ../../Utilities/bsp_drive/: bsp_adc.c bsp_i2c_touch.c bsp_mpu.c bsp_ts_gt911.c exmc_sdram.c gd32f527b_eval.c gd32f527b_lcd_eval.c lcd_font.c sdcard.c touch_panel.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F527/Source/: system_gd32f527.c
  group Doc
    ../../: README.md
  group fatfs
    ../../Utilities/fatfs/fatfs/: ff.c ffsystem.c ffunicode.c
  group fatfs_port
    ../../Utilities/fatfs/fatfs_port/: diskio.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Utilities/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Utilities/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Utilities/lvgl/lvgl/src/extra/: lv_extra.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../Utilities/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Utilities/lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Utilities/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Utilities/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Utilities/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c lv_port_indev.c
  group Peripherals
    ../../Firmware/GD32F527_standard_peripheral/Source/: gd32f527_adc.c gd32f527_can.c gd32f527_cau.c gd32f527_cau_aes.c gd32f527_cau_des.c gd32f527_cau_tdes.c gd32f527_crc.c gd32f527_ctc.c gd32f527_dac.c gd32f527_dbg.c gd32f527_dci.c gd32f527_dma.c gd32f527_enet.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_fwdgt.c gd32f527_gpio.c gd32f527_hau.c gd32f527_hau_sha_md5.c gd32f527_i2c.c gd32f527_i2c_add.c gd32f527_ipa.c gd32f527_iref.c gd32f527_misc.c gd32f527_pkcau.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_rtc.c gd32f527_sai.c gd32f527_sdio.c gd32f527_spi.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_tli.c gd32f527_trng.c gd32f527_usart.c gd32f527_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F527/Source/IAR/: startup_gd32f527.s
  group ui_app
    ../GUI_APP/ui_lvgl/: fatfs_file_browse.c lv_about.c lv_demo_app.c lv_demo_picture.c lv_demo_qrcode.c lv_demo_setting.c lv_file_browse.c
    ../GUI_APP/ui_lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../GUI_APP/ui_lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../GUI_APP/ui_lvgl/demos/stress/: lv_demo_stress.c
    ../GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c
    ../GUI_APP/ui_lvgl/demos/benchmark/assets/: lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group ui_resource
    ../GUI_APP/ui_lvgl/assets/Image/: arail_bold_10.c deguo_32.c german_arial_reg_10.c image_file_28.c image_folder_16.c image_folder_28.c image_folder_32.c img_about.c img_about_pressed.c img_background.c img_bmp.c img_file.c img_file_16.c img_file_32.c img_gd_logo.c img_home.c img_home_pressed.c img_mem.c img_music.c img_music_pressed.c img_open_bmp.c img_open_gif.c img_open_jpg.c img_open_png.c img_picture.c img_png.c img_qrcode.c img_setting.c img_sjpg.c img_speed.c img_speed_pressed.c img_temp.c img_widget.c img_widget_pressed.c japan_tanugo_reg_10.c lv_customer_font_SourceHanSerifSC_Regular_10.c lv_font_digital_20.c lv_font_digital_30.c meiguo_32.c riben_32.c wave.c wuxinghongqi_32.c yahei_regular_10.c
    ../GUI_APP/ui_lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c
    ../GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../GUI_APP/ui_lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
